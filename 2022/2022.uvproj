# Keil uVision project 2022.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 2022 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\2022
  group Source Group 1
    ./: main.c ds1302.c onewire.c iic.c
