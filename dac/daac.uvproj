# Keil uVision project daac.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: daac +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\dac
  group Source Group 1
    ./: iic.c main.c
