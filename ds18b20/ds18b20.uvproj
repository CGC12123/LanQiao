# Keil uVision project ds18b20.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\ds18b20
  group Source Group 1
    ./: STARTUP.A51 ds18b20.c onewire.c
