# Keil uVision project de1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: de1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\ds1302new
  group Source Group 1
    ./: ds1302.c main.c
